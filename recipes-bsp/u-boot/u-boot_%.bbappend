FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:reframe = " file://reframe-bootdelay.cfg"
