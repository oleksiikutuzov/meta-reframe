PACKAGECONFIG:append = " wifi dnsmasq nmcli"
