FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-rpi-initialize-buffer-index-before-stream-lookup.patch"
