FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-core-Switch-libcamera-string-controls-to-use-std-str.patch"
