SUMMARY = "Python library for reading and writing EXIF data"
HOMEPAGE = "https://github.com/hMatoba/Piexif"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=de3294fd570f87ece3b7ab7ccd61a108"

PYPI_PACKAGE = "piexif"
PYPI_PACKAGE_EXT = "zip"

inherit pypi setuptools3

SRC_URI[sha256sum] = "83cb35c606bf3a1ea1a8f0a25cb42cf17e24353fd82e87ae3884e74a302a5f1b"
